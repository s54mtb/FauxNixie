# Keil uVision project FauxNixieSegment.uvprojx, settings and files
target FauxNixieSegment (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G031J6Mx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: FauxNixieSegment
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\HAL\Inc;.\HAL\Inc\Legacy;.\APP
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group HAL
    ./HAL/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_cec.c stm32g0xx_hal_comp.c stm32g0xx_hal_cortex.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_cryp.c stm32g0xx_hal_cryp_ex.c stm32g0xx_hal_dac.c stm32g0xx_hal_dac_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_fdcan.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_hcd.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_i2s.c stm32g0xx_hal_irda.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_lptim.c stm32g0xx_hal_pcd.c stm32g0xx_hal_pcd_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_rng.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_smartcard.c stm32g0xx_hal_smartcard_ex.c stm32g0xx_hal_smbus.c stm32g0xx_hal_smbus_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_usart.c stm32g0xx_hal_usart_ex.c stm32g0xx_hal_wwdg.c stm32g0xx_ll_adc.c stm32g0xx_ll_comp.c stm32g0xx_ll_crc.c stm32g0xx_ll_crs.c stm32g0xx_ll_dac.c stm32g0xx_ll_dma.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_i2c.c stm32g0xx_ll_lptim.c stm32g0xx_ll_lpuart.c stm32g0xx_ll_pwr.c stm32g0xx_ll_rcc.c stm32g0xx_ll_rng.c stm32g0xx_ll_rtc.c stm32g0xx_ll_spi.c stm32g0xx_ll_tim.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_usart.c stm32g0xx_ll_usb.c stm32g0xx_ll_utils.c
  group APP
    ./APP/: main.c stm32g0xx_hal_conf.h MCU_Init.c serial_handler.c
  group OLED
    ./APP/: oled.c fonts.c gfx.c oled_handler.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.4.0
